# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\mcu_fun\inc;.\driver\inc;.\hardware\inc;.\user;.\NET\net_task;.\NET\onenet\inc;.\NET\MQTT;.\NET\device\inc;.\framework;.\tlsf
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_i2c.c
  group mcu_fun
    ./mcu_fun/src/: mcu_adc.c mcu_dma.c mcu_exti.c mcu_gpio.c mcu_nvic.c mcu_rcc.c mcu_spi.c mcu_timer.c mcu_usart.c mcu_i2c.c
  group driver
    ./driver/src/: adc.c delay.c hwtimer.c i2c.c rtc.c spi.c usart.c
  group hardware
    ./hardware/src/: at24c02.c beep.c lcd1602.c key.c led.c sht20.c spilcd.c ADXL362.c light.c ir.c nec.c
  group user
    ./user/: main.c FONT.c dataStreamName.h
  group net_task
    ./NET/net_task/: net_task.c
  group OneNET
    ./NET/onenet/src/: onenet.c fault.c dStream.c cmd_callback.c protocol_parser.c
  group net_protocol
    ./NET/MQTT/: MqttKit.c
  group net_device
    ./NET/device/src/: net_io.c net_device.c
  group framework
    ./framework/: framework.c
  group TLSF
    ./tlsf/: tlsf.c
software components: CMSIS:CORE 4.3.0
